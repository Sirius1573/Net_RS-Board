# Keil uVision project Project.uvprojx, settings and files
target complete (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\SYSTEM\sys;..\HARDWARE\OCEP;..\HARDWARE\USART;..\HARDWARE\W5500;..\SYSTEM\delay;..\HARDWARE\REMOTE;..\HARDWARE\AT24C512;..\HARDWARE\KEY;..\HARDWARE\SCIO;..\HARDWARE\DataPackage;..\SYSTEM\usart;..\HARDWARE\ESP01;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/OCEP/: OCEP.c
    ../HARDWARE/USART/: USART.c
    ../HARDWARE/W5500/: W5500.c
    ../HARDWARE/REMOTE/: Remote.c
    ../HARDWARE/AT24C512/: 24cxx.c
    ../HARDWARE/SCIO/: SCIO.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/DataPackage/: DataPackage.c
    ../HARDWARE/ESP01/: ESP01.c
    ../HARDWARE/TIMER/: Timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
